# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: main
  c flags: Optim=1
  group Source Group 1
    ./: main.c adc_driver.c Random.s Nokia5110.c adc_driver.h Random.h Nokia511.h
    ../driver/: gpio.c gpio_cfg.c gpio.h gpio_cfg.h MATH_LIB.h
    ../Timer0/: Timer0.c Timer_0.h
    ../ADC_lab - Copy (2)/: tm4c123gh6pm11.h
